# IAR project Wdg.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Wdg.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: main.cpp
  group Apps/CommandManager
    ./: CommandManager.cpp CommandManager.h
  group Apps/Common
    ./: IRebooter.h IResetController.h ISubscriber.h
  group Apps/ResetController
    ./: ResetController.cpp ResetController.h
  group Drivers/Clock
    ./: Clock.cpp Clock.h
  group Drivers/Rebooter
    ./: GpioRebooter.cpp GpioRebooter.h
  group Drivers/ResetTimer
    ./: ResetTimer.cpp ResetTimer.h
  group Drivers/BaseTimer
    ./: BaseTimer.cpp BaseTimer.h
  group Drivers/Uart
    ./: Uart.cpp Uart.h
